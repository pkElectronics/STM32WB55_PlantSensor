# Keil uVision project STM32WB55_PlantSensor.uvprojx, settings and files
target STM32WB55_PlantSensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32WB55_PlantSensor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_HAL_DRIVER,STM32WB55xx
  c include: ../Inc;      ../Drivers/STM32WBxx_HAL_Driver/Inc;      ../Utilities/lpm/tiny_lpm;      ../tiny_lpm;      ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;      ../Middlewares/Third_Party/FatFs/src;      ../Middlewares/ST/STM32_WPAN;      ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;      ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;      ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;      ../Middlewares/ST/STM32_WPAN/utilities;      ../Middlewares/ST/STM32_WPAN/ble/core;      ../Middlewares/ST/STM32_WPAN/ble/core/auto;      ../Middlewares/ST/STM32_WPAN/ble/core/template;      ../Middlewares/ST/STM32_WPAN/ble/svc/Inc;      ../Middlewares/ST/STM32_WPAN/ble/svc/Src;      ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;      ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;      ../Drivers/CMSIS/Device/ST/STM32WBxx/Include;      ../Utilities/sequencer;      ../Middlewares/ST/STM32_WPAN/ble;      ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: main.c user_diskio.c app_fatfs.c app_entry.c hw_timerserver.c stm32_lpm_if.c app_ble.c p2p_server_app.c hw_ipcc.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/ChargeTransferSensing
    ../Src/: pke_charge_transfer.c
    ../Inc/: pke_charge_transfer.h
  group Application/SI7021
    ../Src/: pke_si7021_handler.c
    ../Inc/: pke_si7021_handler.h
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_gpio.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c p2p_stm.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
software components: CMSIS:CORE 4.3.0
